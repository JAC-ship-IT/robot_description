Commit message: update

File: assets/urdf/table_narrow.urdf (robot description, URDF)
Before this commit: robot box, 1 links, 0 joints
Links:
- link box: geometry collision box size=0.475 0.6 0.35; visual box size=0.475 0.6 0.35
